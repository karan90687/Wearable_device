## master_node/sdkconfig.defaults
```kconfig
# ESP-NOW master node defaults
CONFIG_ESP_WIFI_SOFTAP_SUPPORT=n
CONFIG_ESP_WIFI_NAN_ENABLE=n
CONFIG_FREERTOS_HZ=1000
```
